RDEPENDS:${PN} += " \
    python3-zoneinfo \
"

